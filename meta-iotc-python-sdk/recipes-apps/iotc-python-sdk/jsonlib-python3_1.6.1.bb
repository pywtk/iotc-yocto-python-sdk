SUMMARY = "JSON serializer/deserializer for Python"
    
HOMEPAGE = "https://launchpad.net/jsonlib"
LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/GPL-3.0-only;md5=c79ff39f19dfec6d293b95dea7b07891"

SRC_URI[md5sum] = "e16bbafabdbb6500bdca701a0bc6f370"
SRC_URI[sha256sum] = "39a3b58d3e4eb3f4172f0e7c6c386c064384a1bd7be9cf41e44fb806835b775c"

PYPI_PACKAGE = "jsonlib-python3"   

inherit pypi setuptools3